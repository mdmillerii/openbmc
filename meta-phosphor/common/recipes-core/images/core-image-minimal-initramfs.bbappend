PACKAGE_INSTALL_remove = "initramfs-live-boot initramfs-live-install initramfs-live-install-efi"
PACKAGE_INSTALL += "obmc-phosphor-initfs"
PACKAGE_INSTALL += "obmc-phosphor-initfs-ram"
INITRAMFS_FSTYPES = "cpio.${INITRAMFS_CTYPE}"
